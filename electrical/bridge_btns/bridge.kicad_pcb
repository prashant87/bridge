# Repository prashant87/bridge

## KiCad design electrical/bridge_btns/bridge.kicad_pcb

Parts:
C1, C3: 18p; C_0603_1608Metric
C2, C6, C7, C8, C12, C13: 100n; C_0603_1608Metric
C4, C5, C9: 4u7; C_0603_1608Metric
C10, C11: 2u2; C_0603_1608Metric
D1, D2: LED; LED_D3.0mm
J1, J2: MY_USB_B; USB_B_Horizontal
J3: swd; PinHeader_1x03_P1.27mm_Vertical
J4: Conn_01x05; PinHeader_1x05_P1.27mm_Vertical
J5: Conn_01x07; PinHeader_1x07_P1.27mm_Vertical
J6, J7: Conn_01x14; PinHeader_1x14_P1.27mm_Vertical
P1: ~rst~; PinHeader_1x02_P1.27mm_Vertical
P2: bootldr; PinHeader_1x02_P1.27mm_Vertical
R1, R2, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R18, R19: 10k 5%; R_0603_1608Metric
R3, R4: 1k 5%; R_0603_1608Metric
R5: 100 5%; R_0603_1608Metric
U1: crystal-4pin; CRYSTAL-SMD-5x3
U2: stm32f405rgt6
U3: my-NCP1117ST50T3G; SOT-223

Connections:
/boot0: P2.2, R1.2, U2.60 (BOOT0)
/clk-in: C1.2, U1.3 (xtal2), U2.5 (PD0_OSC_IN)
/clk-out: R5.1, U2.6 (PD1_OSC_OUT)
/dev_dm: J1.2 (D-), U2.44 (PA11___OTG_FS_DM)
/dev_dp: J1.3 (D+), U2.45 (PA12___OTG_FS_DP)
/host_dm: J2.2 (D-), U2.35 (PB14___OTG_HS_DM)
/host_dp: J2.3 (D+), U2.36 (PB15___OTG_HS_DP)
/i2c_scl: J4.4, R19.1, U2.58 (PB6__USART1_TX)
/i2c_sda: J4.5, R18.1, U2.59 (PB7__USART1_RX)
/led-0: R3.1, U2.15 (PA1)
/led-1: R4.1, U2.16 (PA2)
/pa4: J6.4, R16.1, U2.20 (PA4)
/pa5: J6.5, R15.1, U2.21 (PA5)
/pa6: J6.6, R14.1, U2.22 (PA6)
/pa7: J6.7, R13.1, U2.23 (PA7)
/pb0: J6.10, R10.1, U2.26 (PB0)
/pb1: J6.11, R9.1, U2.27 (PB1)
/pb2: J6.12, R8.1, U2.28 (PB2)
/pb10: J6.13, R7.1, U2.29 (PB10___USART3_TX)
/pb11: J6.14, R6.1, U2.30 (PB11___USART3_RX)
/pc4: J6.8, R12.1, U2.24 (PC4)
/pc5: J6.9, R11.1, U2.25 (PC5)
/spi_miso: J5.5, U2.52 (PC11__USART4_RX)
/spi_mosi: J5.4, U2.53 (PC12)
/spi_nss: J5.7, U2.50 (PA15___JTDI)
/spi_sck: J5.6, U2.51 (PC10___USART4_TX)
/swd_clk: J3.1, U2.49 (PA14___JTCK-SWCLK)
/swd_io: J3.3, U2.46 (PA13___JTMS-SWDIO)
/vbus: C4.1, C9.1, J1.1 (VBUS), J2.1 (VBUS), J4.1, J5.1, J6.1, U3.3 (VI)
/~mcu-rst~: C2.1, P1.1, R2.2, U2.7 (NRST)
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.1, C11.1, C12.2, C13.2, D1.2 (A), D2.2 (A), J1.4 (GND), J1.5 (Shield), J2.4 (GND), J2.5 (Shield), J3.2, J4.3, J5.3, J6.3, J7.1, J7.2, J7.3, J7.4, J7.5, J7.6, J7.7, J7.8, J7.9, J7.10, J7.11, J7.12, J7.13, J7.14, P1.2, R1.1, U1.2, U1.4, U2.12 (VssA), U2.18 (Vss_1), U2.63 (Vss_2), U3.1 (GND)
unnamed: C3.1, R5.2, U1.1 (xtal)
unnamed: C10.2, U2.31 (Vcap_1)
unnamed: C11.2, U2.47 (Vcap_2)
unnamed: D1.1 (K), R3.2
unnamed: D2.1 (K), R4.2
VDD: C5.1, C6.1, C7.1, C8.1, C12.1, C13.1, J4.2, J5.2, J6.2, P2.1, R2.1, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R18.2, R19.2, U2.1 (VBAT), U2.13 (VDDA), U2.19 (VDD_4), U2.32 (VDD_1), U2.48 (VDD_2), U2.64 (VDD_3), U3.2 (VO), U3.4 (VO)

Notes on the sheet:
If Vbus drops too low consider poweroff. Switch to higher voltage from boost regulator to live longer.
According to datasheet this one is mandatory for stability.
Device
Low speed: 1.5 Mb/s Full speed: 12 Mb/s High speed: 480 Mb/s
Host

Board: 2 copper layers, 39.5 x 32.5 mm, 45 parts (20 on the bottom side), 37 nets.

## KiCad design electrical/emg_preamp_2/amg_preamp_2.kicad_pcb

Parts:
C1, C6: 4u7; C_0603_1608Metric
C2, C3, C4, C5, C7, C8, C9, C10: 2n2; C_0603_1608Metric
C11, C12: 100n; C_0603_1608Metric
J1: CONN_01X01; PinHeader_1x01_P1.27mm_Vertical
J2: test; TestPoint_Pad_D1.0mm
J3: Conn_01x05; PinHeader_1x05_P1.27mm_Vertical
R1: 1k5 1%; R_0603_1608Metric
R2, R9: 1M 1%; R_0603_1608Metric
R3, R10: 100R 1%; R_0603_1608Metric
R4, R5, R7, R8, R12, R13: 3R; R_0603_1608Metric
R6, R11: 100k 1%; R_0603_1608Metric
R14: 1k 1%; R_0603_1608Metric
U1, U2, U3: ad8603; TSOT-23-5

Connections:
/one: C2.1, C6.2, R6.1, U1.1 (out)
/out: J3.3, R14.2
/two: C8.1, J2.1, R11.1, R14.1, U3.1 (out)
/v_ref: R2.2, R3.2, R9.2, R10.2, U2.1 (out), U2.4 (in-)
/v_ref_in: C12.1, J3.5, U2.3 (in+)
GNDA: C3.2, C4.2, C5.2, C7.2, C9.2, C10.2, C11.2, C12.2, J3.2, J3.4, R5.2, R8.2, R13.2
unnamed: C1.1, R1.1, R2.1, U1.3 (in+)
unnamed: C1.2, J1.1, R1.2
unnamed: C2.2, R3.1, R6.2, U1.4 (in-)
unnamed: C3.1, R5.1, U1.2 (v-)
unnamed: C6.1, R9.1, U3.3 (in+)
unnamed: C7.1, R8.1, U2.2 (v-)
unnamed: C8.2, R10.1, R11.2, U3.4 (in-)
unnamed: C9.1, R13.1, U3.2 (v-)
unnamed: R4.2, U1.5 (v+)
unnamed: R7.2, U2.5 (v+)
unnamed: R12.2, U3.5 (v+)
VDDA: C4.1, C5.1, C10.1, C11.1, J3.1, R4.1, R7.1, R12.1

Notes on the sheet:
Long wires after a socket may introduce noise as it typically happens at opamp output with presence of a capacitance. A resistance is supposed to help a little bit. So that opamp output works on a little piece of wire before the resistance.

Board: 2 copper layers, 31.5 x 11.5 mm, 32 parts (14 on the bottom side), 18 nets.

## Code that names these connections

File cubemx_project/bridge_btns/test/Src/gpio.c:

/**
  ******************************************************************************
  * File Name          : gpio.c
  * Description        : This file provides code for the configuration
  *                      of all used GPIO pins.
  ******************************************************************************
  * @attention
  *
  * <h2><center>&copy; Copyright (c) 2019 STMicroelectronics.
  * All rights reserved.</center></h2>
  *
  * This software component is licensed by ST under Ultimate Liberty license
  * SLA0044, the "License"; You may not use this file except in compliance with
  * the License. You may obtain a copy of the License at:
  *                             www.st.com/SLA0044
  *
  ******************************************************************************
  */

/* Includes ------------------------------------------------------------------*/
#include "gpio.h"
/* USER CODE BEGIN 0 */

/* USER CODE END 0 */

/*----------------------------------------------------------------------------*/
/* Configure GPIO                                                             */
/*----------------------------------------------------------------------------*/
/* USER CODE BEGIN 1 */

/* USER CODE END 1 */

/** Configure pins as 
        * Analog 
        * Input 
        * Output
        * EVENT_OUT
        * EXTI
*/
void MX_GPIO_Init(void)
{

  GPIO_InitTypeDef GPIO_InitStruct = {0};

  /* GPIO Ports Clock Enable */
  __HAL_RCC_GPIOH_CLK_ENABLE();
  __HAL_RCC_GPIOA_CLK_ENABLE();
  __HAL_RCC_GPIOC_CLK_ENABLE();
  __HAL_RCC_GPIOB_CLK_ENABLE();

  /*Configure GPIO pin Output Level */
  HAL_GPIO_WritePin(GPIOA, GPIO_PIN_1|GPIO_PIN_2, GPIO_PIN_RESET);

  /*Configure GPIO pins : PA1 PA2 */
  GPIO_InitStruct.Pin = GPIO_PIN_1|GPIO_PIN_2;
  GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_LOW;
  HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);

  /*Configure GPIO pins : PA4 PA5 PA6 PA7 */
  GPIO_InitStruct.Pin = GPIO_PIN_4|GPIO_PIN_5|GPIO_PIN_6|GPIO_PIN_7;
  GPIO_InitStruct.Mode = GPIO_MODE_INPUT;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);

  /*Configure GPIO pins : PC4 PC5 */
  GPIO_InitStruct.Pin = GPIO_PIN_4|GPIO_PIN_5;
  GPIO_InitStruct.Mode = GPIO_MODE_INPUT;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(GPIOC, &GPIO_InitStruct);

  /*Configure GPIO pins : PB0 PB1 PB2 PB10 
                           PB11 */
  GPIO_InitStruct.Pin = GPIO_PIN_0|GPIO_PIN_1|GPIO_PIN_2|GPIO_PIN_10 
                          |GPIO_PIN_11;
  GPIO_InitStruct.Mode = GPIO_MODE_INPUT;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(GPIOB, &GPIO_InitStruct);

}

/* USER CODE BEGIN 2 */

/* USER CODE END 2 */

/************************ (C) COPYRIGHT STMicroelectronics *****END OF FILE****/

File cubemx_project/emg/Src/stm32f4xx_hal_msp.c:

/**
  ******************************************************************************
  * File Name          : stm32f4xx_hal_msp.c
  * Description        : This file provides code for the MSP Initialization 
  *                      and de-Initialization codes.
  ******************************************************************************
  * This notice applies to any and all portions of this file
  * that are not between comment pairs USER CODE BEGIN and
  * USER CODE END. Other portions of this file, whether 
  * inserted by the user or by software development tools
  * are owned by their respective copyright owners.
  *
  * Copyright (c) 2018 STMicroelectronics International N.V. 
  * All rights reserved.
  *
  * Redistribution and use in source and binary forms, with or without 
  * modification, are permitted, provided that the following conditions are met:
  *
  * 1. Redistribution of source code must retain the above copyright notice, 
  *    this list of conditions and the following disclaimer.
  * 2. Redistributions in binary form must reproduce the above copyright notice,
  *    this list of conditions and the following disclaimer in the documentation
  *    and/or other materials provided with the distribution.
  * 3. Neither the name of STMicroelectronics nor the names of other 
  *    contributors to this software may be used to endorse or promote products 
  *    derived from this software without specific written permission.
  * 4. This software, including modifications and/or derivative works of this 
  *    software, must execute solely and exclusively on microcontroller or
  *    microprocessor devices manufactured by or for STMicroelectronics.
  * 5. Redistribution and use of this software other than as permitted under 
  *    this license is void and will automatically terminate your rights under 
  *    this license. 
  *
  * THIS SOFTWARE IS PROVIDED BY STMICROELECTRONICS AND CONTRIBUTORS "AS IS" 
  * AND ANY EXPRESS, IMPLIED OR STATUTORY WARRANTIES, INCLUDING, BUT NOT 
  * LIMITED TO, THE IMPLIED WARRANTIES OF MERCHANTABILITY, FITNESS FOR A 
  * PARTICULAR PURPOSE AND NON-INFRINGEMENT OF THIRD PARTY INTELLECTUAL PROPERTY
  * RIGHTS ARE DISCLAIMED TO THE FULLEST EXTENT PERMITTED BY LAW. IN NO EVENT 
  * SHALL STMICROELECTRONICS OR CONTRIBUTORS BE LIABLE FOR ANY DIRECT, INDIRECT,
  * INCIDENTAL, SPECIAL, EXEMPLARY, OR CONSEQUENTIAL DAMAGES (INCLUDING, BUT NOT
  * LIMITED TO, PROCUREMENT OF SUBSTITUTE GOODS OR SERVICES; LOSS OF USE, DATA, 
  * OR PROFITS; OR BUSINESS INTERRUPTION) HOWEVER CAUSED AND ON ANY THEORY OF 
  * LIABILITY, WHETHER IN CONTRACT, STRICT LIABILITY, OR TORT (INCLUDING 
  * NEGLIGENCE OR OTHERWISE) ARISING IN ANY WAY OUT OF THE USE OF THIS SOFTWARE,
  * EVEN IF ADVISED OF THE POSSIBILITY OF SUCH DAMAGE.
  *
  ******************************************************************************
  */
/* Includes ------------------------------------------------------------------*/
#include "stm32f4xx_hal.h"

extern DMA_HandleTypeDef hdma_adc1;

extern void _Error_Handler(char *, int);
/* USER CODE BEGIN 0 */

/* USER CODE END 0 */
/**
  * Initializes the Global MSP.
  */
void HAL_MspInit(void)
{
  /* USER CODE BEGIN MspInit 0 */

  /* USER CODE END MspInit 0 */

  __HAL_RCC_SYSCFG_CLK_ENABLE();
  __HAL_RCC_PWR_CLK_ENABLE();

  HAL_NVIC_SetPriorityGrouping(NVIC_PRIORITYGROUP_4);

  /* System interrupt init*/
  /* MemoryManagement_IRQn interrupt configuration */
  HAL_NVIC_SetPriority(MemoryManagement_IRQn, 0, 0);
  /* BusFault_IRQn interrupt configuration */
  HAL_NVIC_SetPriority(BusFault_IRQn, 0, 0);
  /* UsageFault_IRQn interrupt configuration */
  HAL_NVIC_SetPriority(UsageFault_IRQn, 0, 0);
  /* SVCall_IRQn interrupt configuration */
  HAL_NVIC_SetPriority(SVCall_IRQn, 0, 0);
  /* DebugMonitor_IRQn interrupt configuration */
  HAL_NVIC_SetPriority(DebugMonitor_IRQn, 0, 0);
  /* PendSV_IRQn interrupt configuration */
  HAL_NVIC_SetPriority(PendSV_IRQn, 15, 0);
  /* SysTick_IRQn interrupt configuration */
  HAL_NVIC_SetPriority(SysTick_IRQn, 15, 0);

  /* USER CODE BEGIN MspInit 1 */

  /* USER CODE END MspInit 1 */
}

void HAL_ADC_MspInit(ADC_HandleTypeDef* hadc)
{

  GPIO_InitTypeDef GPIO_InitStruct;
  if(hadc->Instance==ADC1)
  {
  /* USER CODE BEGIN ADC1_MspInit 0 */

  /* USER CODE END ADC1_MspInit 0 */
    /* Peripheral clock enable */
    __HAL_RCC_ADC1_CLK_ENABLE();
  
    /**ADC1 GPIO Configuration    
    PA0-WKUP     ------> ADC1_IN0
    PA1     ------> ADC1_IN1
    PA2     ------> ADC1_IN2
    PA3     ------> ADC1_IN3
    PA4     ------> ADC1_IN4
    PA5     ------> ADC1_IN5
    PA6     ------> ADC1_IN6 
    */
    GPIO_InitStruct.Pin = GPIO_PIN_0|GPIO_PIN_1|GPIO_PIN_2|GPIO_PIN_3 
                          |GPIO_PIN_4|GPIO_PIN_5|GPIO_PIN_6;
    GPIO_InitStruct.Mode = GPIO_MODE_ANALOG;
    GPIO_InitStruct.Pull = GPIO_NOPULL;
    HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);

    /* ADC1 DMA Init */
    /* ADC1 Init */
    hdma_adc1.Instance = DMA2_Stream0;
    hdma_adc1.Init.Channel = DMA_CHANNEL_0;
    hdma_adc1.Init.Direction = DMA_PERIPH_TO_MEMORY;
    hdma_adc1.Init.PeriphInc = DMA_PINC_DISABLE;
    hdma_adc1.Init.MemInc = DMA_MINC_ENABLE;
    hdma_adc1.Init.PeriphDataAlignment = DMA_PDATAALIGN_HALFWORD;
    hdma_adc1.Init.MemDataAlignment = DMA_MDATAALIGN_HALFWORD;
    hdma_adc1.Init.Mode = DMA_CIRCULAR;
    hdma_adc1.Init.Priority = DMA_PRIORITY_LOW;
    hdma_adc1.Init.FIFOMode = DMA_FIFOMODE_DISABLE;
    if (HAL_DMA_Init(&hdma_adc1) != HAL_OK)
    {
      _Error_Handler(__FILE__, __LINE__);
    }

    __HAL_LINKDMA(hadc,DMA_Handle,hdma_adc1);

    /* ADC1 interrupt Init */
    HAL_NVIC_SetPriority(ADC_IRQn, 5, 0);
    HAL_NVIC_EnableIRQ(ADC_IRQn);
  /* USER CODE BEGIN ADC1_MspInit 1 */

  /* USER CODE END ADC1_MspInit 1 */
  }

}

void HAL_ADC_MspDeInit(ADC_HandleTypeDef* hadc)
{

  if(hadc->Instance==ADC1)
  {
  /* USER CODE BEGIN ADC1_MspDeInit 0 */

  /* USER CODE END ADC1_MspDeInit 0 */
    /* Peripheral clock disable */
    __HAL_RCC_ADC1_CLK_DISABLE();
  
    /**ADC1 GPIO Configuration    
    PA0-WKUP     ------> ADC1_IN0
    PA1     ------> ADC1_IN1
    PA2     ------> ADC1_IN2
    PA3     ------> ADC1_IN3
    PA4     ------> ADC1_IN4
    PA5     ------> ADC1_IN5
    PA6     ------> ADC1_IN6 
    */
    HAL_GPIO_DeInit(GPIOA, GPIO_PIN_0|GPIO_PIN_1|GPIO_PIN_2|GPIO_PIN_3 
                          |GPIO_PIN_4|GPIO_PIN_5|GPIO_PIN_6);

    /* ADC1 DMA DeInit */
    HAL_DMA_DeInit(hadc->DMA_Handle);

    /* ADC1 interrupt DeInit */
    HAL_NVIC_DisableIRQ(ADC_IRQn);
  /* USER CODE BEGIN ADC1_MspDeInit 1 */

  /* USER CODE END ADC1_MspDeInit 1 */
  }

}

/* USER CODE BEGIN 1 */

/* USER CODE END 1 */

/**
  * @}
  */

/**
  * @}
  */

/************************ (C) COPYRIGHT STMicroelectronics *****END OF FILE****/

## Commit log

2018-01-21 Initial revision.
2018-01-21 Generated component for max3421e.
2018-01-21 Drawings and urls for components.
2018-01-21 My old components which might be useful.
2018-01-25 Copied all footprints. Drew approximate schematic.
2018-01-26 Improving component.
2018-01-26 Saved project.
2018-01-27 F405 with two interfaces.
2018-01-28 Making a schematic.
2018-01-29 Designing schematic.
2018-01-31 Making pcb.
2018-02-03 Done with routing.
2018-02-03 Components with digikey URLs.
2018-02-05 Examples.
2018-07-05 Added project examples. And generated projects files from CubeMx project file.
2018-07-05 Looks like the problem was caused by initializing all (including SWD) pins to be analog.
2018-07-05 Mouse data goes to PC and affects mouse pointer as expected.
2018-07-05 When reading data using host interface device stops working.
2018-07-05 With these changes host enters the most inner piece and reads mouse information.
2018-07-05 A few more examples.
2018-07-05 Device works.
2018-07-05 Mouse through works. Need add buttons.
2018-07-05 Buttons work as well.
2018-07-05 Removed artificial drift along X axis.
2018-07-06 Added bmi160 driver. But didn't compile anything with it yet. May be I'll simply use BMX055.
2018-07-06 Just in case save complimentary filter source.
2018-07-07 Ignoring "_temp" folder.
2018-07-07 I2C example.
2018-07-07 Generated project with I2C support.
2018-07-07 BNO055 works.
2018-07-08 Mouse output adjustment.
2018-07-12 Something happens.
2018-07-12 It seems this is the right way to send data.
2018-07-15 Case.
2018-07-23 Design.
2018-09-07 emg-sensing.
2018-09-14 Components for emg.
2018-09-18 Making two separate boards. One for ADC and the other one for preamplification.
2018-09-18 Added output resistance to preamp board.
2018-09-19 Added filtering bypass caps.
2018-09-20 Done with digital part. More or less...
2018-09-20 Connected grounds undernear the MCU.
2018-09-20 Added Digikey links.
2018-09-30 Replaced components with the ones available for shipping immediately.
2018-10-10 ODE joint creation manual.
2018-10-11 Generated project.
2018-10-12 Regenerated project with virtual serial port support.
2018-10-13 Added 2 GP implementations.
2018-10-15 Also taken into account LED GPIOs.
2018-10-24 CMake creates project.
2018-10-24 It compiles.
2018-10-25 Debugging...
2018-10-25 This way USB power doesn't disappear.
2018-10-25 Still no power problem but ADC isn't working.
2018-10-25 So far no success.
2018-10-25 Regenerated with ADC proper configuration. But lost almost all custom code. Need to restore it.
2018-10-26 ADC reads data and sends to transmit routine.
2018-10-26 Swapped "D-" and "D+" due to schematic error. Now USB works.
2018-10-26 Data reception works.
2018-10-26 Plot drawing works.
2018-10-27 Now ADC reads all 7 channels.
2018-11-01 Another board with single (not differential) amplification. It means 2x less inputs. It might be too small amount to recognize movements properly.
2018-11-01 Composed bom for that board.
2018-11-07 Added optimization to Release build configuration.
2018-11-07 This one compiles and runs at least in debug mode.
2018-11-07 Increased IO timeout to match current data rate which should be ~100 samples per second compared to previous 6100 which was too high.
2018-11-08 This computation shows I can insert a capacitor and still have high gain with simultaneously reducing instrumentation amplifier gain. But need to lower it's amplification to make signal in range even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
2018-11-09 Adjustable limits.
2018-11-15 Increased data throughput to ~1k samples/sec.
2018-11-20 Holders...
2018-11-20 Documented changes.
2018-11-23 Started gp tryout.
2018-11-24 Have some output.
2018-11-27 AL binding works.
2018-11-27 In process of adding sound into the application.
2018-11-27 Added classifier.
2018-11-27 Data preparation routine.
2018-12-04 Adjusted a little bit. Now it is more stable.
2018-12-05 A few fixes...
2018-12-05 Making save/load.
2018-12-06 Working on file streaming.
2018-12-06 Save/Load.
2018-12-06 Assigning hyperparameters and checked save/load.
2018-12-06 Added papers.
2018-12-07 Fitter compiles.
2018-12-07 Hand with skeleton.
2018-12-07 Hand with animation and compositing.
2019-05-18 A version with extra IOs.
2019-05-18 Updated CubeMX file.
2019-05-18 Done with layout.
2019-05-18 Ordered components.
2019-06-12 Generated project files.
2019-06-12 Generated with FreeRTOS support.
2019-07-11 Works down to reading IMU data. And IMU is not connected yet. So might be ok.
2019-07-12 Reads sensor fine.
2019-07-12 Reads sensor but doesn't move mouse. It is because USB devices are mixed up.
2019-07-12 Removed another USB.
2019-07-13 Manually overwritten generated USB initialization. This way mouse emulation works.
2019-07-13 Generated in a separate folder using the newest CubeMX with FreeRTOS_V1 support. This way it compiles and both USB interfaces work.
2019-07-13 Filling in speed control.
2019-07-14 Adding things...
2019-07-14 In process...
2019-07-14 Adjusting the holder.
2019-07-15 PSB holder.
2019-07-15 Support
2020-03-31 Renamed strange file names.
2020-03-31 Fixing paths.

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
