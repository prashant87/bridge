# Repository prashant87/bridge (continued)

## KiCad design electrical/emg/emg.kicad_pcb

Parts:
C1, C9: 18p; C_0603_1608Metric
C2, C15, C19: 2n2; C_0603_1608Metric
C3, C4, C5, C7, C8, C10, C16, C17, C18, C20, C21, C22, C24: 100n; C_0603_1608Metric
C6, C13, C14, C23, C25, C26: 4u7; C_0603_1608Metric
C11, C12: 2u2; C_0603_1608Metric
D1, D2, D3: LED; LED_D3.0mm
J1: USB_B; USB_B_Horizontal
J2: swd; PinHeader_1x03_P1.27mm_Vertical
J3, J7, J8, J14, J15, J16, J17: T3; TestPoint_Pad_D1.0mm
J4, J5, J6, J9, J11, J12, J13: Conn_01x05; Pin_Header_Straight_1x05_Pitch1.27mm
J10: Ref; Pin_Header_Straight_1x05_Pitch1.27mm
P1: ~rst~; PinHeader_1x02_P1.27mm_Vertical
P2: bootldr; PinHeader_1x02_P1.27mm_Vertical
R1, R2: 10k 5%; R_0603_1608Metric
R3, R4, R5: 1k 5%; R_0603_1608Metric
R6, R7: 100 5%; R_0603_1608Metric
R8, R9: 10k 1%; R_0603_1608Metric
R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R25, R33, R34, R35, R36, R37, R38, R39: 1k 1%; R_0603_1608Metric
R24: 10 5%; R_0603_1608Metric
R26, R27, R28, R29, R30, R31, R32: 100k 1%; R_0603_1608Metric
R260: 47k1%; R_0603_1608Metric
TP100, TP101, TP102, TP103: M3; MountingHole_3.2mm_M3_DIN965_Pad
U1: stm32f405rgt6
U2: crystal-4pin; CRYSTAL-SMD-5x3
U3, U4: my-NCP1117ST50T3G; SOT-223
U5, U6: TSV734IPT; TSSOP-14_4.4x5mm_P0.65mm

Connections:
/boot0: P2.2, R1.2, U1.60 (BOOT0)
/clk-in: C1.2, U1.5 (PD0_OSC_IN), U2.3 (xtal2)
/clk-out: R6.1, U1.6 (PD1_OSC_OUT)
/dev_dm: J1.2 (D-), U1.36 (PB15___OTG_HS_DP)
/dev_dp: J1.3 (D+), U1.35 (PB14___OTG_HS_DM)
/in_0: R35.2, U1.14 (PA0-WKUP)
/in_1: R34.2, U1.15 (PA1)
/in_2: R33.2, U1.16 (PA2)
/in_3: R36.2, U1.17 (PA3)
/in_4: R37.2, U1.20 (PA4)
/in_5: R38.2, U1.21 (PA5)
/in_6: R39.2, U1.22 (PA6)
/led-0: R3.1, U1.55 (PB3)
/led-1: R4.1, U1.56 (PB4)
/led-2: R5.1, U1.57 (PB5)
/swd_clk: J2.1, U1.49 (PA14___JTCK-SWCLK)
/swd_io: J2.3, U1.46 (PA13___JTMS-SWDIO)
/v_0: J4.3, R28.2, U5.12 (in+)
/v_1: J5.3, R27.2, U5.10 (in+)
/v_2: J6.3, R26.2, U5.5 (in+)
/v_3: J9.3, R29.2, U6.3 (in+)
/v_4: J11.3, R30.2, U6.5 (in+)
/v_5: J12.3, R31.2, U6.10 (in+)
/v_6: J13.3, R32.2, U6.12 (in+)
/v_ref: C23.1, J4.5, J5.5, J6.5, J9.5, J11.5, J12.5, J13.5, R10.1, R11.1, R12.1, R15.1, R16.1, R18.1, R19.1, R24.1, R26.1, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1, R260.2
/vbus: C6.1, C26.1, J1.1 (VBUS), U3.3 (VI), U4.3 (VI)
/~mcu-rst~: C4.1, P1.1, R2.2, U1.7 (NRST)
GND: C1.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.2, D1.2 (A), D2.2 (A), D3.2 (A), J1.4 (GND), J1.5 (Shield), J2.2, P1.2, R1.1, R7.2, U1.18 (Vss_1), U1.63 (Vss_2), U2.2, U2.4, U3.1 (GND)
GNDA: C2.2, C3.2, C14.2, C15.2, C19.2, C23.2, C25.2, C26.2, J4.2, J4.4, J5.2, J5.4, J6.2, J6.4, J9.2, J9.4, J11.2, J11.4, J12.2, J12.4, J13.2, J13.4, R7.1, R9.2, R260.1, TP100.1, TP101.1, TP102.1, TP103.1, U1.12 (VssA), U4.1 (GND), U5.11 (V-), U6.11 (V-)
unnamed: C9.1, R6.2, U2.1 (xtal)
unnamed: C11.2, U1.31 (Vcap_1)
unnamed: C12.2, U1.47 (Vcap_2)
unnamed: C16.1, J3.1, R17.2, R33.1, U5.7 (out)
unnamed: C16.2, R10.2, R17.1, U5.6 (in-)
unnamed: C17.1, J7.1, R13.2, R34.1, U5.8 (out)
unnamed: C17.2, R11.2, R13.1, U5.9 (in-)
unnamed: C18.1, J8.1, R14.2, R35.1, U5.14 (out)
unnamed: C18.2, R12.2, R14.1, U5.13 (in-)
unnamed: C20.1, J14.1, R20.2, R36.1, U6.1 (out)
unnamed: C20.2, R15.2, R20.1, U6.2 (in-)
unnamed: C21.1, J15.1, R21.2, R37.1, U6.7 (out)
unnamed: C21.2, R16.2, R21.1, U6.6 (in-)
unnamed: C22.1, J16.1, R22.2, R38.1, U6.8 (out)
unnamed: C22.2, R18.2, R22.1, U6.9 (in-)
unnamed: C24.1, J17.1, R23.2, R39.1, U6.14 (out)
unnamed: C24.2, R19.2, R23.1, U6.13 (in-)
unnamed: C25.1, J10.1, J10.2, J10.3, J10.4, J10.5, R25.1
unnamed: D1.1 (K), R3.2
unnamed: D2.1 (K), R4.2
unnamed: D3.1 (K), R5.2
unnamed: R8.2, R9.1, U5.3 (in+)
unnamed: R24.2, R25.2, U5.1 (out), U5.2 (in-)
VDD: C5.1, C7.1, C8.1, C10.1, C13.1, P2.1, R2.1, U1.1 (VBAT), U1.19 (VDD_4), U1.32 (VDD_1), U1.48 (VDD_2), U1.64 (VDD_3), U3.2 (VO), U3.4 (VO)
VDDA: C2.1, C3.1, C14.1, C15.1, C19.1, J4.1, J5.1, J6.1, J9.1, J11.1, J12.1, J13.1, R8.1, U1.13 (VDDA), U4.2 (VO), U4.4 (VO), U5.4 (v+), U6.4 (v+)

Notes on the sheet:
According to datasheet this one is mandatory for stability.
USB devices
Low speed: 1.5 Mb/s Full speed: 12 Mb/s High speed: 480 Mb/s

Board: 4 copper layers, 70.0 x 37.0 mm, 98 parts (2 on the bottom side), 54 nets.

File emg_bom/bom_emg.csv:

Id	Designator	Package	Quantity	Designation	Supplier and ref
1	C1,C9	C_0603_1608Metric	2	18p	https://www.digikey.com/product-detail/en/samsung-electro-me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
2	C2,C15,C19	C_0603_1608Metric	3	2n2	https://www.digikey.com/product-detail/en/murata-electronics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
3	C3,C4,C5,C7,C8,C10,C16,C17,C18,C20,C21,C22,C24	C_0603_1608Metric	13	100n	https://www.digikey.com/product-detail/en/tdk-corporation/C1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
4	C6,C13,C14,C23,C25,C26	C_0603_1608Metric	6	4u7	https://www.digikey.com/product-detail/en/samsung-electro-me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
5	C11,C12	C_0603_1608Metric	2	2u2	https://www.digikey.com/product-detail/en/murata-electronics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
6	D1,D2,D3	LED_D3.0mm	3	LED	https://www.digikey.com/product-detail/en/inolux/INL-3AR30/1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
7	J1	USB_B_Horizontal	1	USB_B	https://www.digikey.com/product-detail/en/on-shore-technolog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
8	J2	PinHeader_1x03_P1.27mm_Vertical	1	swd	
9	J3,J7,J8,J14,J17,J15,J16	TestPoint_Pad_D1.0mm	7	T3	
10	P1	PinHeader_1x02_P1.27mm_Vertical	1	~rst~	
11	P2	PinHeader_1x02_P1.27mm_Vertical	1	bootldr	
12	R1,R2	R_0603_1608Metric	2	10k 5%	https://www.digikey.com/product-detail/en/yageo/RC0603JR-071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
13	R3,R4,R5	R_0603_1608Metric	3	1k 5%	https://www.digikey.com/product-detail/en/yageo/RC0603JR-071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
14	R6,R7	R_0603_1608Metric	2	100 5%	https://www.digikey.com/product-detail/en/bourns-inc/CR0603-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
15	R8,R9	R_0603_1608Metric	2	10k 1%	https://www.digikey.com/product-detail/en/vishay-beyschlag/M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
16	R10,R11,R12,R13,R14,R15,R16,R17,R18,R19,R20,R21,R22,R23,R25,R33,R34,R35,R36,R37,R38,R39	R_0603_1608Metric	22	1k 1%	https://www.digikey.com/product-detail/en/vishay-beyschlag/M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
17	R24	R_0603_1608Metric	1	10 5%	https://www.digikey.com/product-detail/en/yageo/RC0603FR-071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
18	U1	stm32f405rgt6	1	stm32f405rgt6	https://www.digikey.com/product-detail/en/stmicroelectronics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
19	U2	CRYSTAL-SMD-5x3	1	crystal-4pin	https://www.digikey.com/product-detail/en/diodes-incorporate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
20	U3,U4	SOT-223	2	my-NCP1117ST50T3G	https://www.digikey.com/product-detail/en/on-semiconductor/N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
21	U5,U6	TSSOP-14_4.4x5mm_P0.65mm	2	TSV734IPT	https://www.digikey.com/product-detail/en/stmicroelectronics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
22	R260	R_0603_1608Metric	1	47k1%	https://www.digikey.com/product-detail/en/yageo/RC0603FR-074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
23	J4,J5,J6,J9,J11,J12,J13	Pin_Header_Straight_1x05_Pitch1.27mm	7	Conn_01x05	
24	TP100,TP101,TP102,TP103	MountingHole_3.2mm_M3_DIN965_Pad	4	M3	
25	R26,R27,R28,R29,R30,R31,R32	R_0603_1608Metric	7	100k 1%	https://www.digikey.com/product-detail/en/ERJ-3EKF1003V/P100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
26	J10	Pin_Header_Straight_1x05_Pitch1.27mm	1	Ref	https://www.digikey.com/product-detail/en/harwin-inc/M50-353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
				female 40pins	https://www.digikey.com/product-detail/en/chip-quik-inc/HDR1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

## KiCad design electrical/emg_preamp/amg_preamp.kicad_pcb

Parts:
C1, C2: 22n; C_0603_1608Metric
C3, C4, C6: 100n; C_0603_1608Metric
C5: 2n2; C_0603_1608Metric
J1: in; Pin_Header_Straight_1x02_Pitch1.27mm
J2: T1; TestPoint_Pad_D1.0mm
J3: T2; TestPoint_Pad_D1.0mm
J4: Conn_01x05; Pin_Header_Straight_1x05_Pitch1.27mm
R1, R2, R5, R6: 1k5 1%; R_0603_1608Metric
R3, R4: 1M 1%; R_0603_1608Metric
R7: 150 1%; R_0603_1608Metric
R8, R9: 47k1%; R_0603_1608Metric
R10, R11, R12, R13: 10k 1%; R_0603_1608Metric
R14, R16: 1k 1%; R_0603_1608Metric
R15: 100k 1%; R_0603_1608Metric
U1: TSZ124IPT; TSSOP-14_4.4x5mm_P0.65mm

Connections:
/out: J4.3, R16.2
/v_ref: J4.5, R3.2, R4.2, R13.2, U1.10 (in+)
GNDA: C3.2, C4.2, C5.2, J4.2, J4.4, U1.11 (V-)
unnamed: C1.1, R1.1, R3.1, R5.2
unnamed: C1.2, J1.1, R1.2
unnamed: C2.1, R2.1, R4.1, R6.2
unnamed: C2.2, J1.2, R2.2
unnamed: C3.1, R5.1, U1.3 (in+)
unnamed: C4.1, R6.1, U1.5 (in+)
unnamed: C6.1, J3.1, R15.2, R16.1, U1.8 (out)
unnamed: C6.2, R14.2, R15.1, U1.9 (in-)
unnamed: J2.1, R12.2, R14.1, U1.14 (out)
unnamed: R7.1, R8.2, U1.2 (in-)
unnamed: R7.2, R9.2, U1.6 (in-)
unnamed: R8.1, R10.1, U1.1 (out)
unnamed: R10.2, R12.1, U1.13 (in-)
unnamed: R9.1, R11.1, U1.7 (out)
unnamed: R11.2, R13.1, U1.12 (in+)
VDDA: C5.1, J4.1, U1.4 (v+)

Notes on the sheet:
Long wires after a socket may introduce noise as it typically happens at opamp output with presence of a capacitance. A resistance is supposed to help a little bit. So that opamp output works on a little piece of wire before the resistance.

Board: 2 copper layers, 29.0 x 13.5 mm, 27 parts (2 on the bottom side), 19 nets.

File emg_bom/bom_emg_preamp.csv:

Id	Designator	Package	Quantity	Designation	Supplier and ref
1	C1,C2	C_0603_1608Metric	2	22n	https://www.digikey.com/product-detail/en/tdk-corporation/CG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
2	C3,C4,C6,C7,C8	C_0603_1608Metric	5	100n	https://www.digikey.com/product-detail/en/CL10B104KO8NNNC/12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
3	C5	C_0603_1608Metric	1	2n2	https://www.digikey.com/product-detail/en/murata-electronics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
4	J1	Pin_Header_Straight_1x02_Pitch1.27mm	1	in	
5	J2	TestPoint_Pad_D1.0mm	1	T1	
6	J3	TestPoint_Pad_D1.0mm	1	T2	
7	J4	Pin_Header_Straight_1x05_Pitch1.27mm	1	Conn_01x05	https://www.digikey.com/product-detail/en/harwin-inc/M50-353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
8	R1,R2,R5,R6	R_0603_1608Metric	4	1k5 1%	https://www.digikey.com/product-detail/en/stackpole-electron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
9	R3,R4	R_0603_1608Metric	2	1M 1%	https://www.digikey.com/product-detail/en/yageo/RC0603FR-071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
10	R7	R_0603_1608Metric	1	150 1%	https://www.digikey.com/product-detail/en/panasonic-electron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
11	R8,R9	R_0603_1608Metric	2	47k1%	https://www.digikey.com/product-detail/en/yageo/RC0603FR-074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
12	R10,R11,R12,R13	R_0603_1608Metric	4	10k 1%	https://www.digikey.com/product-detail/en/vishay-beyschlag/M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
13	R14,R16	R_0603_1608Metric	2	1k 1%	https://www.digikey.com/product-detail/en/vishay-beyschlag/M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
14	R15	R_0603_1608Metric	1	100k 1%	https://www.digikey.com/product-detail/en/te-connectivity-pa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
15	U1	TSSOP-14_4.4x5mm_P0.65mm	1	TSZ124IPT	https://www.digikey.com/product-detail/en/stmicroelectronics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

## KiCad design electrical/lcu03/lcu03.kicad_pcb

Board: 2 copper layers, 99.5 x 50.0 mm, 120 parts (0 on the bottom side), 94 nets.

Parts:
C1, C4, C5, C8, C9, C10, C11, C14, C15, C23, C24, C26, C27, C28, C29, C31, C32, C33, C34, C35, C37, C38: 100n; C_0805
C2, C3: 18p; C_0805
C6, C7, C12, C13, C18, C21: 4u7; C_0805
C16: 10n; C_0805
C19: 2n2; C_0805
C22, C25: 680u; C_Radial_D10_L20_P5
C30, C36: 220n; C_0805
D1, D2: LED; LED-3MM
D3, D4: 1n5819; Diode_DO-41_SOD81_Horizontal_RM10
L1: 10uH; R_1206_HandSoldering
L2: 100uH; my_inductance
P1, P2, P3, P4, P16, P17: screw; MountingHole_3mm
P5: ext-1; Pin_Header_Straight_1x08
P6: ~rst~; Measurement_Point_Round-TH_Small
P7: mode; Pin_Header_Straight_1x02
P8: ext-2; Pin_Header_Straight_1x08
P9: USB_B
P10: swd; Pin_Header_Straight_1x03
P11, P12, P13, P14, P15: stepper_conn; my-JST_B4B-PH-SM4-TB
Q1: bc857; SOT-23
Q4: ntd18n06l; my-DPAK
R1, R4, R5, R7, R8, R9, R10, R11, R19, R27, R47: 10k 5%; R_0805
R2, R3, R13, R20, R25, R34, R36: 1k 5%; R_0805
R6, R37, R38, R41, R42, R45, R46, R48: 100 5%; R_0805
R12: 0.15 5%; C_1206
R14, R15: ferrite bead; R_0805
R16: 6k2 5%; R_0805
R17: 47k 5%; R_0805
R18, R21, R22, R23, R33, R35: 33k 5%; R_0805
R24: 10 5%; Resistor_Horizontal_RM10mm
R26: 100k 5%; R_0805
R28, R29, R30, R31, R32: 0; R_0805
R39, R40, R43, R44: 1 5%; R_0805
U1: crystal-4pin; CRYSTAL-SMD-5x3
U2: CP2102
U3: m24c02; SOIC-8_3.9x4.9mm_Pitch1.27mm
U4: NCP3063; SOIC-8_3.9x4.9mm_Pitch1.27mm
U5: my-NCP1117ST50T3G; SOT-223
U6: ts881; SOT-23-5
U7: lb1930mc
U8, U9: a4985
U10: MCP1703T-3302E/CB; SOT-23
stm1: STM32F103CBT6; LQFP48

Connections:
/Vbus: C13.1, C15.1, P5.1, P9.1, P12.1, P13.1, R12.2, R15.2, R17.1, U2.8, U4.6
/boot0: P7.2, R5.2, stm1.44
/boot1: R7.2, stm1.20
/clk-in: C2.2, U1.3, stm1.5
/clk-out: R6.1, stm1.6
/cts: U2.23, stm1.33
/d+: P9.3, U2.4
/d-: P9.2, U2.5
/ext-power-flag: U6.1, stm1.45
/gpio-0: P8.5, stm1.29
/gpio-1: P8.6, stm1.28
/gpio-2: P8.7, stm1.27
/gpio-3: P8.8, stm1.19
/hall1: R33.2, R34.2, stm1.15
/hall2: R35.2, R36.2, stm1.25
/i2c1-scl: P5.3, R10.2, U3.6, stm1.42
/i2c1-sda: P5.4, R11.2, U3.5, stm1.43
/led-0: R2.1, stm1.3
/led-1: R3.1, stm1.2
/reg-fb: C16.1, C24.1, C25.1, D4.1, L1.2, P8.3, R14.2, R16.1
/rts: U2.24, stm1.32
/rx-2: P5.7, R4.2, stm1.13
/rxd: R47.2, U2.25, stm1.30
/shutter-a: U7.3, stm1.10
/shutter-b: U7.4, stm1.4
/shutter-out-a: R24.2, R32.2, U7.9
/shutter-out-b: P11.3, P11.4, U7.7
/stepper-subcircuit-1/Vbb: C22.1, C26.1, C29.2, C32.1, C35.2, C38.1, L1.1, U7.1, U8.16, U8.21, U9.16, U9.21
/stepper-subcircuit-1/dir: R38.2, stm1.22
/stepper-subcircuit-1/ms1: R28.2, R29.1, U8.5, U9.5
/stepper-subcircuit-1/ms2: R30.2, R31.1, U8.6, U9.6
/stepper-subcircuit-1/out1a: P14.3, U8.18
/stepper-subcircuit-1/out1b: P14.4, U8.15
/stepper-subcircuit-1/out2a: P14.2, U8.19
/stepper-subcircuit-1/out2b: P14.1, U8.22
/stepper-subcircuit-1/ref: C31.1, C37.1, R23.2, R26.2, R27.1, U8.12, U9.12
/stepper-subcircuit-1/rsense1: R40.2, U8.17
/stepper-subcircuit-1/rsense2: R39.2, U8.20
/stepper-subcircuit-1/step: R37.2, stm1.18
/stepper-subcircuit-1/~enable~: U8.23, U9.23, stm1.21
/stepper-subcircuit-1/~reset~: U8.7, U9.7, stm1.17
/stepper-subcircuit-1/~sleep~: U8.9, U9.9, stm1.16
/stepper-subcircuit-2/dir: R42.2, stm1.14
/stepper-subcircuit-2/out1a: P15.3, U9.18
/stepper-subcircuit-2/out1b: P15.4, U9.15
/stepper-subcircuit-2/out2a: P15.2, U9.19
/stepper-subcircuit-2/out2b: P15.1, U9.22
/stepper-subcircuit-2/rsense1: R44.2, U9.17
/stepper-subcircuit-2/rsense2: R43.2, U9.20
/stepper-subcircuit-2/step: R41.2, stm1.11
/suspend: U2.12, stm1.41
/swd-clk: P10.3, stm1.37
/swd-io: P10.1, stm1.34
/tx-2: P5.6, stm1.12
/txd: U2.26, stm1.31
/~high-current~: R19.1, R20.2, stm1.26
/~mcu-rst~: C4.1, P6.1, R8.2, stm1.7
/~wc~: R9.2, U3.7, stm1.46
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C18.2, C19.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C30.2, C31.2, C32.2, C33.2, C36.2, C37.2, C38.2, D1.2, D2.2, P1.1, P2.1, P3.1, P4.1, P5.2, P5.5, P5.8, P8.2, P8.4, P9.4, P9.5, P10.2, P11.0, P12.0, P12.2, P13.0, P13.2, P14.0, P15.0, P16.1, P17.1, Q4.3, R5.1, R7.1, R13.2, R18.2, R22.2, R25.2, R27.2, R29.2, R31.2, R33.1, R35.1, R39.1, R40.1, R43.1, R44.1, R45.1, R46.1, U1.2, U1.4, U2.0, U2.3, U3.1, U3.2, U3.3, U3.4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
unnamed: C1.1, R1.2, U2.9
unnamed: C3.1, R6.2, U1.1
unnamed: C7.1, U2.18
unnamed: C16.2, R13.1, R16.2, U4.5
unnamed: C18.1, D3.1, U5.3, U10.3
unnamed: C19.1, U4.3
unnamed: C28.1, U8.1
unnamed: C28.2, U8.2
unnamed: C29.1, U8.3
unnamed: C30.1, U8.4
unnamed: C34.1, U9.1
unnamed: C34.2, U9.2
unnamed: C35.1, U9.3
unnamed: C36.1, U9.4
unnamed: D1.1, R2.2
unnamed: D2.1, R3.2
unnamed: D3.2, R14.1, R15.1
unnamed: D4.2, L2.2, Q4.4
unnamed: L2.1, R12.1, U4.1, U4.7
unnamed: P11.1, P11.2, R24.1, R32.1
unnamed: P12.3, R34.1
unnamed: P13.3, R36.1
unnamed: Q1.1, R20.1
unnamed: Q1.3, R23.1
unnamed: Q4.1, R25.1, R48.1
unnamed: R17.2, R18.1, U6.3
unnamed: R21.2, R22.1, U6.4
unnamed: R37.1, U8.11
unnamed: R38.1, U8.14
unnamed: R41.1, U9.11
unnamed: R42.1, U9.14
unnamed: R45.2, U8.8
unnamed: R46.2, U9.8
unnamed: R48.2, U4.2
VDD: C5.1, C6.1, C8.1, C9.1, C10.1, C11.1, C12.1, C14.1, C21.1, C23.1, C27.1, C33.1, P7.1, P8.1, Q1.2, R1.1, R4.1, R8.1, R9.1, R10.1, R11.1, R19.2, R21.1, R26.1, R28.1, R30.1, R47.1, U2.6, U2.7, U2.10, U2.13, U2.14, U2.15, U2.16, U2.17, U2.19, U2.20, U2.21, U2.22, U3.8, U5.2, U5.4, U6.5, U8.10, U9.10, U10.2, stm1.1, stm1.9, stm1.24, stm1.36, stm1.48
